<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\app_ospi_random_access.ewp</path>
  </project>
  <batchBuild/>
</workspace>
