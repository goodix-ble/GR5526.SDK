# Keil uVision project graphics_lvgl_831_gpu_demo_360p.uvprojx, settings and files
target GRxx_Soc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: graphics_lvgl_831_gpu_demo_360p +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GR5526_SK,ENV_USE_FREERTOS,LVGL_FRAMEBUFFER_SIZE=16,USE_OSAL,DISP_HOR_RES=360,DISP_VER_RES=360
  c misc: --no-multibyte-chars  --diag_suppress=2751  --locale=english
  c include: ..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_ext\gr55xx;..\..\..\..\..\components\drivers_ext\st7735;..\..\..\..\..\components\drivers_ext\vs1005;..\..\..\..\..\components\drivers_ext\graphics_dc;..\..\..\..\..\components\drivers_ext\qspi_device;..\..\..\..\..\components\libraries\app_alarm;..\..\..\..\..\components\libraries\app_assert;..\..\..\..\..\components\libraries\app_error;..\..\..\..\..\components\libraries\app_key;..\..\..\..\..\components\libraries\app_log;..\..\..\..\..\components\libraries\app_queue;..\..\..\..\..\components\libraries\app_timer;..\..\..\..\..\components\libraries\at_cmd;..\..\..\..\..\components\libraries\dfu_master;..\..\..\..\..\components\libraries\dfu_port;..\..\..\..\..\components\libraries\fault_trace;..\..\..\..\..\components\libraries\gui;..\..\..\..\..\components\libraries\gui\gui_config;..\..\..\..\..\components\libraries\hal_flash;..\..\..\..\..\components\libraries\hci_uart;..\..\..\..\..\components\libraries\pmu_calibration;..\..\..\..\..\components\libraries\ring_buffer;..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\components\libraries\utility;..\..\..\..\..\components\libraries\app_graphics_mem;..\..\..\..\..\components\patch\ind;..\..\..\..\..\components\profiles\ams_c;..\..\..\..\..\components\profiles\ancs_c;..\..\..\..\..\components\profiles\ans;..\..\..\..\..\components\profiles\ans_c;..\..\..\..\..\components\profiles\bas;..\..\..\..\..\components\profiles\bas_c;..\..\..\..\..\components\profiles\bcs;..\..\..\..\..\components\profiles\bps;..\..\..\..\..\components\profiles\common;..\..\..\..\..\components\profiles\cscs;..\..\..\..\..\components\profiles\cts;..\..\..\..\..\components\profiles\cts_c;..\..\..\..\..\components\profiles\dis;..\..\..\..\..\components\profiles\dis_c;..\..\..\..\..\components\profiles\gls;..\..\..\..\..\components\profiles\gus;..\..\..\..\..\components\profiles\gus_c;..\..\..\..\..\components\profiles\hids;..\..\..\..\..\components\profiles\hrrcps;..\..\..\..\..\components\profiles\hrs;..\..\..\..\..\components\profiles\hrs_c;..\..\..\..\..\components\profiles\hts;..\..\..\..\..\components\profiles\ias;..\..\..\..\..\components\profiles\lls;..\..\..\..\..\components\profiles\lms;..\..\..\..\..\components\profiles\ndcs;..\..\..\..\..\components\profiles\otas;..\..\..\..\..\components\profiles\otas_c;..\..\..\..\..\components\profiles\pass;..\..\..\..\..\components\profiles\pass_c;..\..\..\..\..\components\profiles\pcs;..\..\..\..\..\components\profiles\rscs;..\..\..\..\..\components\profiles\rscs_c;..\..\..\..\..\components\profiles\rtus;..\..\..\..\..\components\profiles\sample;..\..\..\..\..\components\profiles\ths;..\..\..\..\..\components\profiles\ths_c;..\..\..\..\..\components\profiles\thscps;..\..\..\..\..\components\profiles\tps;..\..\..\..\..\components\profiles\wechat;..\..\..\..\..\components\sdk\;..\..\..\..\..\components\graphics\gfx\common\;..\..\..\..\..\components\graphics\gfx\common\mem;..\..\..\..\..\components\graphics\gfx\configure;..\..\..\..\..\components\graphics\gfx\include;..\..\..\..\..\components\graphics\gfx\include\tsi;..\..\..\..\..\components\graphics\gfx\include\tsi\common;..\..\..\..\..\components\graphics\gfx\include\tsi\hal_gdc;..\..\..\..\..\components\graphics\gfx\include\tsi\hal_gfx;..\..\..\..\..\components\graphics\gfx\hal_gdc;..\..\..\..\..\components\graphics\gfx\hal_gfx;..\..\..\..\..\components\graphics\gfx\porting;..\..\..\..\..\components\graphics\lvgl_port\lv_port_disp;..\..\..\..\..\components\graphics\lvgl_port\drv_adapter;..\..\..\..\..\components\graphics\lvgl_port\indev_tp_cst816d;..\..\..\..\..\components\graphics\lvgl_port\lv_port_indev;..\..\..\..\..\components\graphics\lvgl_port\lv_port_gr5526;..\..\..\..\..\components\graphics\lvgl_port\os_adapter\FreeRTOS\inc;..\..\..\..\..\components\graphics\lvgl_port\os_adapter\inc;..\..\..\..\..\components\graphics\lvgl_port\os_adapter\shared\inc;..\..\..\..\..\drivers\inc;..\..\..\..\..\drivers\inc\hal;..\..\..\..\..\external\freertos\include;..\..\..\..\..\external\freertos\portable\RVDS\ARM_CM4F;..\..\..\..\..\external\segger_rtt;..\..\..\..\..\external\lvgl_8.3.1\src;..\..\..\..\..\external\lvgl_8.3.1\src\core;..\..\..\..\..\external\lvgl_8.3.1\src\draw;..\..\..\..\..\external\lvgl_8.3.1\src\extra;..\..\..\..\..\external\lvgl_8.3.1\src\extra\layouts;..\..\..\..\..\external\lvgl_8.3.1\src\extra\layouts\flex;..\..\..\..\..\external\lvgl_8.3.1\src\extra\layouts\grid;..\..\..\..\..\external\lvgl_8.3.1\src\extra\libs;..\..\..\..\..\external\lvgl_8.3.1\src\extra\libs\bmp;..\..\..\..\..\external\lvgl_8.3.1\src\extra\libs\freetype;..\..\..\..\..\external\lvgl_8.3.1\src\extra\libs\fsdrv;..\..\..\..\..\external\lvgl_8.3.1\src\extra\libs\gif;..\..\..\..\..\external\lvgl_8.3.1\src\extra\libs\png;..\..\..\..\..\external\lvgl_8.3.1\src\extra\libs\qrcode;..\..\..\..\..\external\lvgl_8.3.1\src\extra\libs\rlottie;..\..\..\..\..\external\lvgl_8.3.1\src\extra\libs\sjpg;..\..\..\..\..\external\lvgl_8.3.1\src\extra\others;..\..\..\..\..\external\lvgl_8.3.1\src\extra\others\snapshot;..\..\..\..\..\external\lvgl_8.3.1\src\extra\themes;..\..\..\..\..\external\lvgl_8.3.1\src\extra\themes\basic;..\..\..\..\..\external\lvgl_8.3.1\src\extra\themes\default;..\..\..\..\..\external\lvgl_8.3.1\src\extra\themes\mono;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\animimg;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\calendar;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\chart;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\colorwheel;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\imgbtn;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\keyboard;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\led;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\list;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\meter;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\msgbox;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\span;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\spinbox;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\spinner;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\tabview;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\tileview;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\win;..\..\..\..\..\external\lvgl_8.3.1\src\font;..\..\..\..\..\external\lvgl_8.3.1\src\misc;..\..\..\..\..\external\lvgl_8.3.1\src\widgets;..\..\..\..\..\external\lvgl_8.3.1\src\hal;..\..\..\..\..\external\lvgl_8.3.1\src\gpu;..\..\..\..\..\external\lvgl_8.3.1\src\gpu\goodix;..\..\..\..\..\external\lvgl_8.3.1;..\..\..\..\..\external\lvgl_8.3.1\src\widgets_gdx\anim_ex;..\..\..\..\..\external\lvgl_8.3.1\src\widgets_gdx\surface_flinger;..\..\..\..\..\external\lvgl_8.3.1\src\gpu\gr552x\porting;..\..\..\..\..\external\lvgl_8.3.1\src\draw\sw;..\..\..\..\..\external\lvgl_8.3.1\src\draw\gr5526_gpu;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\goodix\anim;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\goodix\tileview;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\goodix\menu;..\..\..\..\..\external\lvgl_8.3.1\src\extra\widgets\goodix\scrollbar;..\..\..\..\..\platform\boards;..\..\..\..\..\platform\include;..\..\..\..\..\platform\soc\include;..\..\..\..\..\platform\arch\arm\cortex-m\cmsis\core\include;..\..\..\..\..\platform\soc\linker\keil;..\Src;..\Src\app;..\Src\app\manager;..\Src\app\profiles;..\Src\app\task;..\Src\app\ux_logic;..\Src\config;..\Src\driver;..\Src\lvgl_user_font;..\Src\lvgl_user_font;..\Src\lvgl_user_img;..\Src\lvgl_user_layout;..\Src\lvgl_user_layout\layout_applist;..\Src\lvgl_user_layout\layout_card;..\Src\lvgl_user_layout\layout_setting;..\Src\platform
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x2000a000 size 0x36000
  scatter file: ..\..\..\..\..\platform\soc\linker\keil\flash_scatter_graphics.sct
  link misc: ..\..\..\..\..\platform\soc\linker\keil\rom_symbol.txt
  group gr_startup
    ../../../../../platform/arch/arm/cortex-m/keil/: Startup.S
  group gr_arch
    ../../../../../platform/soc/common/: gr_system.c gr_interrupt.c gr_platform.c
  group gr_soc
    ../../../../../platform/soc/src/: gr_soc.c
  group gr_board
    ../../../../../platform/boards/: board_SK.c
  group gr_stack_lib
    ../../../../../platform/soc/linker/keil/: ble_sdk.lib graphics_sdk.lib graphics_lvgl_v831_lib.lib
    ../Src/lvgl_user_layout/: gw_nebula_core.lib
  group gr_libraries
    ../../../../../components/libraries/utility/: utility.c
    ../../../../../components/libraries/app_timer/: app_timer.c
    ../../../../../components/libraries/ring_buffer/: ring_buffer.c
    ../../../../../components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../../../components/libraries/app_log/: app_log.c app_log_dump_port.c app_log_store.c
    ../../../../../components/libraries/app_error/: app_error.c
    ../../../../../components/libraries/app_assert/: app_assert.c
    ../../../../../components/libraries/app_key/: app_key.c app_key_core.c
    ../../../../../drivers/src/: app_rtc.c
    ../../../../../components/libraries/dfu_port/: dfu_port.c
    ../../../../../components/sdk/: ble.c
  group gr_app_drivers
    ../../../../../drivers/src/: app_dma.c app_gpiote.c app_io.c app_pwr_mgmt.c app_uart.c app_rtos_cfg.c app_qspi.c app_qspi_dma.c app_i2c.c app_i2c_dma.c app_graphics_qspi.c
  group gr_app_graphics
    ../../../../../drivers/src/: app_graphics_dc.c app_graphics_gpu.c app_graphics_ospi.c
    ../../../../../components/libraries/app_graphics_mem/: app_graphics_mem.c
  group freertos
    ../../../../../external/freertos/portable/GR55XX/: port_pm.c
    ../../../../../external/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../external/freertos/: timers.c tasks.c stream_buffer.c queue.c list.c heap_4.c event_groups.c croutine.c
  group lvgl_core
    ../../../../../external/lvgl_8.3.1/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_draw
    ../../../../../external/lvgl_8.3.1/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl_draw_sw
    ../../../../../external/lvgl_8.3.1/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl_draw_gpu
    ../../../../../external/lvgl_8.3.1/src/draw/gr5526_gpu/: lv_gpu_gr5526.c lv_gpu_gr5526.h
  group lvgl_extra
    ../../../../../external/lvgl_8.3.1/src/extra/layouts/flex/: lv_flex.c
    ../../../../../external/lvgl_8.3.1/src/extra/layouts/grid/: lv_grid.c
    ../../../../../external/lvgl_8.3.1/src/extra/themes/basic/: lv_theme_basic.c
    ../../../../../external/lvgl_8.3.1/src/extra/themes/default/: lv_theme_default.c
    ../../../../../external/lvgl_8.3.1/src/extra/themes/mono/: lv_theme_mono.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/animimg/: lv_animimg.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/chart/: lv_chart.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/led/: lv_led.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/list/: lv_list.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/menu/: lv_menu.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/meter/: lv_meter.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/span/: lv_span.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/spinner/: lv_spinner.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/tabview/: lv_tabview.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/tileview/: lv_tileview.c lv_fast_tileview.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/win/: lv_win.c
    ../../../../../external/lvgl_8.3.1/src/extra/: lv_extra.c
  group lvgl_extra.goodix
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/goodix/tileview/: lv_wms_tileview.c lv_wms_surface_flinger.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/goodix/anim/: lv_enhanced_anim.c lv_enhanced_anim.h
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/goodix/menu/: lv_enhanced_grid.c lv_enhanced_list.c lv_circular_list.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/goodix/scrollbar/: lv_enhanced_scrollbar.c
    ../../../../../external/lvgl_8.3.1/src/extra/themes/simplify/: lv_theme_simplify.c
  group lvgl_font
    ../../../../../external/lvgl_8.3.1/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c
  group lvgl_hal
    ../../../../../external/lvgl_8.3.1/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl_misc
    ../../../../../external/lvgl_8.3.1/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_widgets
    ../../../../../external/lvgl_8.3.1/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl_port.device
    ../../../../../components/graphics/lvgl_port/lv_port_disp/: lv_port_disp.c
    ../../../../../components/graphics/lvgl_port/lv_port_indev/: lv_port_indev.c
    ../../../../../components/graphics/lvgl_port/lv_port_gr5526/: lv_port_gr5526.c
  group lvgl_port.graphics
    ../../../../../components/graphics/gfx/porting/: graphics_utils.c graphics_sys_defs.h
  group drv_adapter.wrapper
    ../../../../../components/graphics/lvgl_port/drv_adapter/: drv_adapter_display.h drv_adapter_display.c drv_adapter_norflash.h drv_adapter_norflash.c drv_adapter_touchpad.h drv_adapter_touchpad.c
  group drv_adapter.porting
    ../../../../../components/graphics/lvgl_port/drv_adapter/: drv_adapter_port.h
    ../Src/driver/: drv_adapter_port_disp.c drv_adapter_port_norflash.c drv_adapter_port_touchpad.c
  group drv_adapter.driver
    ../../../../../components/drivers_ext/graphics_dc/: graphics_dc_lcd_drv.h graphics_dc_st77916_qspi_drv.c
    ../../../../../components/drivers_ext/qspi_device/: qspi_norflash_v2.h qspi_norflash_v2.c
    ../../../../../components/graphics/lvgl_port/indev_tp_bf6872/: touchpad_driver.h touchpad_driver.c
    ../../../../../components/graphics/lvgl_port/indev_tp_cst816d/: tp_cst816d_driver.c
  group os_adapter.wrapper
    ../../../../../components/graphics/lvgl_port/os_adapter/shared/src/: osal_heap.c osal_mutex.c osal_queue.c osal_sema.c osal_task.c osal_timer.c
  group os_adapter.impl
    ../../../../../components/graphics/lvgl_port/os_adapter/FreeRTOS/src/: os_impl_heap.c os_impl_mutex.c os_impl_queue.c os_impl_sema.c os_impl_task.c os_impl_timer.c
  group lvgl_user_layout.router
    ../Src/lvgl_user_layout/: lv_layout_router.h lv_layout_router.c
  group lvgl_user_layout.card
    ../Src/lvgl_user_layout/layout_card/: lv_card_watchface_vivid_clock_layout.c lv_card_list_entry_layout.c lv_card_day_activity_statics_layout.c lv_card_layout_heartrate.c lv_card_layout_sleep.c lv_card_layout_stress.c lv_card_layout_weather.c lv_card_notification_layout.c lv_card_status_layout.c
  group lvgl_user_layout.setting
    ../Src/lvgl_user_layout/layout_setting/: lv_layout_settings.c lv_layout_settings_list_style_config.c lv_layout_settings_slide_effect_config.c lv_layout_settings_cardflow_style_config.c lv_layout_settings_power_off.c
  group lvgl_user_layout.applist
    ../Src/lvgl_user_layout/layout_applist/: lv_layout_app_list.c lv_layout_app_grid.c lv_layout_app_dialer.c lv_layout_app_menu.c lv_layout_app_menu.h
  group lvgl_user_layout.other
    ../Src/lvgl_user_layout/: lv_layout_heartrate_chart.c lv_layout_heartrate_statics.c lv_layout_stress_chart.c lv_layout_stress_statics.c lv_layout_spo2.c
  group lvgl_user_images
    ../Src/lvgl_user_img/: lv_img_dsc_list.c lv_img_dsc_list.h
  group lvgl_user_font
    ../../../../../external/lvgl_8.3.1/src/font/: lv_font_montserrat_20.c lv_font_montserrat_30.c lv_font_montserrat_36.c
    ../Src/lvgl_user_font/: lv_font_montserrat_26.c lv_font_montserrat_48.c lv_font_montserrat_48_gdx.c lv_font_msyh_26_gr552x.c lv_font_msyh_20_gr552x.c
  group app.ble_profiles
    ../../../../../components/profiles/gus/: gus.c
    ../../../../../components/profiles/common/: ble_prf_utils.c ble_srv_disc_utils.c
    ../../../../../components/profiles/lms/: lms.c
    ../../../../../components/profiles/otas/: otas.c
    ../Src/app/profiles/: ble_app.c ble_app.h
  group app.platform
    ./../Src/config/: custom_config.h
    ../Src/platform/: user_gpio_diag.c user_periph_setup.c
    ../Src/driver/: bsp_rtc.c bsp_rtc.h
  group app.manager
    ../Src/app/manager/: app_sys_manager.c app_sys_manager.h app_ui_manager.c app_ui_manager.h app_power_manager.c app_power_manager.h
  group app.ux_logic
    ../Src/app/ux_logic/: lv_clock_hands_draw.c lv_clock_hands_draw.h mock_data.c mock_data.h notification_center.c notification_center.h
  group app.task
    ../Src/app/task/: lv_event_task.c lv_user_task.c ota_task.c ota_task.h
  group app.entry
    ../Src/app/: main.c
    ../../../../../external/lvgl_8.3.1/src/extra/others/snapshot/: lv_snapshot.c
    ../../../../../external/lvgl_8.3.1/src/extra/widgets/goodix/anim/: lv_enhanced_anim_rotate.c
