# Keil uVision project graphics_lvgl_810_gpu_demo.uvprojx, settings and files
target GRxx_Soc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: graphics_lvgl_810_gpu_demo +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GR5526_SK,ENV_USE_FREERTOS
  c misc: --no-multibyte-chars --diag_error=warning
  c include: ..\..\..\..\..\build\config;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_ext\gr55xx;..\..\..\..\..\components\drivers_ext\st7735;..\..\..\..\..\components\drivers_ext\vs1005;..\..\..\..\..\components\libraries\app_alarm;..\..\..\..\..\components\libraries\app_assert;..\..\..\..\..\components\libraries\app_error;..\..\..\..\..\components\libraries\app_key;..\..\..\..\..\components\libraries\app_log;..\..\..\..\..\components\libraries\app_queue;..\..\..\..\..\components\libraries\app_timer;..\..\..\..\..\components\libraries\at_cmd;..\..\..\..\..\components\libraries\dfu_master;..\..\..\..\..\components\libraries\dfu_port;..\..\..\..\..\components\libraries\gui;..\..\..\..\..\components\libraries\gui\gui_config;..\..\..\..\..\components\libraries\hal_flash;..\..\..\..\..\components\libraries\hci_uart;..\..\..\..\..\components\libraries\pmu_calibration;..\..\..\..\..\components\libraries\ring_buffer;..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\components\libraries\utility;..\..\..\..\..\components\patch\ind;..\..\..\..\..\components\profiles\ams_c;..\..\..\..\..\components\profiles\ancs_c;..\..\..\..\..\components\profiles\ans;..\..\..\..\..\components\profiles\ans_c;..\..\..\..\..\components\profiles\bas;..\..\..\..\..\components\profiles\bas_c;..\..\..\..\..\components\profiles\bcs;..\..\..\..\..\components\profiles\bps;..\..\..\..\..\components\profiles\common;..\..\..\..\..\components\profiles\cscs;..\..\..\..\..\components\profiles\cts;..\..\..\..\..\components\profiles\cts_c;..\..\..\..\..\components\profiles\dis;..\..\..\..\..\components\profiles\dis_c;..\..\..\..\..\components\profiles\gls;..\..\..\..\..\components\profiles\gus;..\..\..\..\..\components\profiles\gus_c;..\..\..\..\..\components\profiles\hids;..\..\..\..\..\components\profiles\hrrcps;..\..\..\..\..\components\profiles\hrs;..\..\..\..\..\components\profiles\hrs_c;..\..\..\..\..\components\profiles\hts;..\..\..\..\..\components\profiles\ias;..\..\..\..\..\components\profiles\lls;..\..\..\..\..\components\profiles\ndcs;..\..\..\..\..\components\profiles\otas;..\..\..\..\..\components\profiles\otas_c;..\..\..\..\..\components\profiles\pass;..\..\..\..\..\components\profiles\pass_c;..\..\..\..\..\components\profiles\pcs;..\..\..\..\..\components\profiles\rscs;..\..\..\..\..\components\profiles\rscs_c;..\..\..\..\..\components\profiles\rtus;..\..\..\..\..\components\profiles\sample;..\..\..\..\..\components\profiles\ths;..\..\..\..\..\components\profiles\ths_c;..\..\..\..\..\components\profiles\thscps;..\..\..\..\..\components\profiles\tps;..\..\..\..\..\components\profiles\wechat;..\..\..\..\..\components\sdk\;..\..\..\..\..\drivers\inc;..\..\..\..\..\drivers\inc\hal;..\..\..\..\..\external\freertos\include;..\..\..\..\..\external\freertos\portable\RVDS\ARM_CM4F;..\..\..\..\..\external\segger_rtt;..\..\..\..\..\external\lvgl_8.1.0;..\..\..\..\..\external\lvgl_8.1.0\src;..\..\..\..\..\external\lvgl_8.1.0\src\core;..\..\..\..\..\external\lvgl_8.1.0\src\draw;..\..\..\..\..\external\lvgl_8.1.0\src\extra;..\..\..\..\..\external\lvgl_8.1.0\src\extra\layouts;..\..\..\..\..\external\lvgl_8.1.0\src\extra\layouts\flex;..\..\..\..\..\external\lvgl_8.1.0\src\extra\layouts\grid;..\..\..\..\..\external\lvgl_8.1.0\src\extra\libs;..\..\..\..\..\external\lvgl_8.1.0\src\extra\libs\bmp;..\..\..\..\..\external\lvgl_8.1.0\src\extra\libs\freetype;..\..\..\..\..\external\lvgl_8.1.0\src\extra\libs\fsdrv;..\..\..\..\..\external\lvgl_8.1.0\src\extra\libs\gif;..\..\..\..\..\external\lvgl_8.1.0\src\extra\libs\png;..\..\..\..\..\external\lvgl_8.1.0\src\extra\libs\qrcode;..\..\..\..\..\external\lvgl_8.1.0\src\extra\libs\rlottie;..\..\..\..\..\external\lvgl_8.1.0\src\extra\libs\sjpg;..\..\..\..\..\external\lvgl_8.1.0\src\extra\others;..\..\..\..\..\external\lvgl_8.1.0\src\extra\others\snapshot;..\..\..\..\..\external\lvgl_8.1.0\src\extra\themes;..\..\..\..\..\external\lvgl_8.1.0\src\extra\themes\basic;..\..\..\..\..\external\lvgl_8.1.0\src\extra\themes\default;..\..\..\..\..\external\lvgl_8.1.0\src\extra\themes\mono;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\animimg;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\calendar;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\chart;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\colorwheel;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\imgbtn;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\keyboard;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\led;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\list;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\meter;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\msgbox;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\span;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\spinbox;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\spinner;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\tabview;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\tileview;..\..\..\..\..\external\lvgl_8.1.0\src\extra\widgets\win;..\..\..\..\..\external\lvgl_8.1.0\src\font;..\..\..\..\..\external\lvgl_8.1.0\src\misc;..\..\..\..\..\external\lvgl_8.1.0\src\widgets;..\..\..\..\..\external\lvgl_8.1.0\src\hal;..\..\..\..\..\external\lvgl_8.1.0\src\gpu;..\..\..\..\..\external\lvgl_8.1.0\src\gpu\goodix;..\..\..\..\..\external\lvgl_8.1.0\src\gpu\gr552x\porting;..\..\..\..\..\components\drivers_ext\graphics_dc;..\..\..\..\..\components\graphics\gfx\common\;..\..\..\..\..\components\graphics\gfx\common\mem;..\..\..\..\..\components\graphics\gfx\configure;..\..\..\..\..\components\graphics\gfx\include;..\..\..\..\..\components\graphics\gfx\include\tsi;..\..\..\..\..\components\graphics\gfx\include\tsi\common;..\..\..\..\..\components\graphics\gfx\include\tsi\hal_gdc;..\..\..\..\..\components\graphics\gfx\include\tsi\hal_gfx;..\..\..\..\..\components\graphics\gfx\hal_gdc;..\..\..\..\..\components\graphics\gfx\hal_gfx;..\..\..\..\..\components\graphics\gfx\porting;..\..\..\..\..\components\libraries\app_graphics_mem;..\..\..\..\..\components\drivers_ext\qspi_device;..\..\..\..\..\platform\include;..\..\..\..\..\platform\soc\include;..\..\..\..\..\platform\arch\arm\cortex-m\cmsis\core\include;..\..\..\..\..\platform\soc\linker\keil;..\..\..\..\..\platform\boards;..\Src;..\Src\config;..\Src\lvgl_user_font;..\Src\lvgl_user_img;..\Src\lvgl_user_layout;..\Src\lvgl_user_port;..\Src\lvgl_wms_2.0;..\Src\lvgl_wms_2.0\wms_layout;..\Src\platform;..\Src\user;..\Src\user_driver;..\Src\user_driver_disp
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x2000a000 size 0x36000
  scatter file: ..\..\..\..\..\platform\soc\linker\keil\flash_scatter_graphics.sct
  link misc: ..\..\..\..\..\platform\soc\linker\keil\rom_symbol.txt
  group gr_startup
    ../../../../../platform/arch/arm/cortex-m/keil/: Startup.S
  group gr_arch
    ../../../../../platform/soc/common/: gr_system.c gr_interrupt.c gr_platform.c
  group gr_soc
    ../../../../../platform/soc/src/: gr_soc.c
  group gr_board
    ../../../../../platform/boards/: board_SK.c
  group gr_stack_lib
    ../../../../../platform/soc/linker/keil/: ble_sdk.lib graphics_sdk.lib graphics_lvgl_v810_lib.lib
    ../Src/lvgl_user_layout/: gw_nebula_core.lib
  group gr_app_drivers
    ../../../../../drivers/src/: app_dma.c app_gpiote.c app_io.c app_pwr_mgmt.c app_uart.c app_rtos_cfg.c app_qspi.c app_qspi_dma.c app_i2c.c app_i2c_dma.c app_graphics_qspi.c
  group gr_libraries
    ../../../../../components/libraries/utility/: utility.c
    ../../../../../components/libraries/app_timer/: app_timer.c
    ../../../../../components/libraries/ring_buffer/: ring_buffer.c
    ../../../../../components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../../../components/libraries/app_log/: app_log.c
    ../../../../../components/libraries/app_error/: app_error.c
    ../../../../../components/libraries/app_assert/: app_assert.c
    ../../../../../components/libraries/app_key/: app_key.c app_key_core.c
    ../../../../../drivers/src/: app_rtc.c
  group gr_app_graphics
    ../../../../../drivers/src/: app_graphics_dc.c app_graphics_gpu.c app_graphics_ospi.c
    ../../../../../components/libraries/app_graphics_mem/: app_graphics_mem.c
  group graphics.display_drv
    ../../../../../components/drivers_ext/graphics_dc/: graphics_dc_lcd_drv.h graphics_dc_rm69330_qspi_drv.c graphics_dc_amo139_qspi_drv.c
  group graphics.porting
    ../Src/user_driver_disp/: graphics_defs.h
    ../../../../../components/graphics/gfx/porting/: graphics_utils.c graphics_sys_defs.h
  group freertos
    ../../../../../external/freertos/portable/GR55XX/: port_pm.c
    ../../../../../external/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../external/freertos/: timers.c tasks.c stream_buffer.c queue.c list.c heap_4.c event_groups.c croutine.c
  group user_platform
    ./../Src/config/: custom_config.h
    ../Src/platform/: user_gpio_diag.c user_periph_setup.c
  group user_layout
    ../../../../../external/lvgl_8.1.0/src/gpu/gr552x/porting/: lv_wms.h lv_wms.c lv_wms_surface_flinger.c lv_wms_surface_flinger.h
    ../Src/lvgl_user_layout/: lv_layout_manager.h lv_layout_manager.c lv_status_bar_layout.c lv_message_layout.c lv_activity_layout.c lv_heartrate_layout.c lv_list_view_select_layout.c lv_mars_clock_layout.c lv_flower_clock_layout.c lv_setting_layout.c lv_switch_effect_layout.c lv_clock_view_select_layout.c lv_clock_hands_draw.c lv_black_clock_layout.c lv_cube_clock_layout.c lv_custom_obj.c lv_debug_mode_layout.c lv_graphics_arc_layout.c lv_graphics_circle_layout.c lv_graphics_cube_layout.c lv_graphics_draw.c lv_graphics_jump_layout.c lv_graphics_stencil_layout.c lv_graphics_tsc4_layout.c lv_nebula.c lv_nebula_layout.c lv_scale_list.c lv_scale_list_layout.c lv_switch_list_layout.c lv_volume_adjust_layout.c lv_chart_layout.c lv_widgets_test_layout.c
  group user_app
    ../Src/user/: main.c lv_user_task.c
  group user_driver
    ../../../../../components/drivers_ext/qspi_device/: qspi_flash.c
    ../Src/user_driver/: tp_config.c bsp_tp.c
    ../Src/user_driver_disp/: disp_driver.c disp_driver.h
  group lvgl_user_port
    ../Src/lvgl_user_port/: lv_port_indev.c lv_port_disp.c lv_port_fs.c
    ../../../../../external/lvgl_8.1.0/src/: lv_conf_internal.h
  group lvgl_user_font
    ../Src/lvgl_user_img/: lv_img_dsc_list.h lv_img_dsc_list.c
    ../../../../../external/lvgl_8.1.0/src/font/: lv_font_unscii_8.c lv_font_montserrat_40.c lv_font_montserrat_16.c lv_font_montserrat_8.c lv_font_montserrat_20.c
    ../Src/lvgl_user_font/: lv_font_msyhbd_34.c lv_font_msyhbd_40.c lv_font_simsun_22.c lv_font_simsun_28.c lv_font_simsun_34.c lv_font_simsun_40.c lv_font_symbol_40.c lv_font_unscii_40.c
  group lvgl_core
    ../../../../../external/lvgl_8.1.0/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group lvgl_draw
    ../../../../../external/lvgl_8.1.0/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lvgl_extra
    ../../../../../external/lvgl_8.1.0/src/extra/: lv_extra.c
    ../../../../../external/lvgl_8.1.0/src/extra/layouts/flex/: lv_flex.c
    ../../../../../external/lvgl_8.1.0/src/extra/layouts/grid/: lv_grid.c
    ../../../../../external/lvgl_8.1.0/src/extra/themes/basic/: lv_theme_basic.c
    ../../../../../external/lvgl_8.1.0/src/extra/themes/default/: lv_theme_default.c
    ../../../../../external/lvgl_8.1.0/src/extra/themes/mono/: lv_theme_mono.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/animimg/: lv_animimg.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/chart/: lv_chart.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/led/: lv_led.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/list/: lv_list.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/meter/: lv_meter.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/span/: lv_span.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/spinner/: lv_spinner.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/tabview/: lv_tabview.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/tileview/: lv_tileview.c
    ../../../../../external/lvgl_8.1.0/src/extra/widgets/win/: lv_win.c
  group lvgl_font
    ../../../../../external/lvgl_8.1.0/src/font/: lv_font.c lv_font_fmt_txt.c lv_font_loader.c
  group lvgl_hal
    ../../../../../external/lvgl_8.1.0/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lvgl_misc
    ../../../../../external/lvgl_8.1.0/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lvgl_widgets
    ../../../../../external/lvgl_8.1.0/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group lvgl_wms_2.0
    ../../../../../external/lvgl_8.1.0/src/gpu/gr552x/porting/: lv_wms_v2.c lv_wms_scene.h lv_wms_scene.c lv_wms_key_handler.c
    ../Src/lvgl_wms_2.0/wms_layout/: layout_scene_manage.h layout_scene_manage.c
    ../Src/lvgl_wms_2.0/: lv_card_watchface_layout.c lv_card_list_entry_layout.c lv_card_message_layout.c lv_card_status_layout.c lv_card_day_activity_statics_layout.c lv_card_heartrate_layout.c lv_card_spo2_layout.c lv_card_stress_layout.c lv_card_sleep_layout.c lv_card_music_layout.c lv_card_nfc_layout.c lv_list_menu_layout.c lv_sports_layout.c
