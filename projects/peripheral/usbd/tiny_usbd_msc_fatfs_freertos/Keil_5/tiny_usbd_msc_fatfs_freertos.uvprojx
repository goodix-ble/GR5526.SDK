# Keil uVision project tiny_usbd_msc_fatfs_freertos.uvprojx, settings and files
target GRxx_Soc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: tiny_usbd_msc_fatfs_freertos +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: DRIVER_TEST,ENV_USE_FREERTOS
  c misc: --gnu
  c include: ..\Src\platform;..\Src\user;..\Src\config;..\..\..\..\..\components\app_drivers\inc;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_ext\gr55xx;..\..\..\..\..\components\libraries\app_alarm;..\..\..\..\..\components\libraries\app_assert;..\..\..\..\..\components\libraries\app_error;..\..\..\..\..\components\libraries\app_key;..\..\..\..\..\components\libraries\app_log;..\..\..\..\..\components\libraries\app_queue;..\..\..\..\..\components\libraries\app_timer;..\..\..\..\..\components\libraries\at_cmd;..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\components\libraries\dfu_master;..\..\..\..\..\components\libraries\dfu_port;..\..\..\..\..\components\libraries\gui;..\..\..\..\..\components\libraries\gui\gui_config;..\..\..\..\..\components\libraries\hal_flash;..\..\..\..\..\components\libraries\hci_uart;..\..\..\..\..\components\libraries\pmu_calibration;..\..\..\..\..\components\libraries\ring_buffer;..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\components\libraries\fault_trace;..\..\..\..\..\components\libraries\utility;..\..\..\..\..\components\patch\ind;..\..\..\..\..\components\profiles\ams_c;..\..\..\..\..\components\profiles\ancs_c;..\..\..\..\..\components\profiles\ans;..\..\..\..\..\components\profiles\ans_c;..\..\..\..\..\components\profiles\bas;..\..\..\..\..\components\profiles\bas_c;..\..\..\..\..\components\profiles\bcs;..\..\..\..\..\components\profiles\bps;..\..\..\..\..\components\profiles\common;..\..\..\..\..\components\profiles\cscs;..\..\..\..\..\components\profiles\cts;..\..\..\..\..\components\profiles\cts_c;..\..\..\..\..\components\profiles\dis;..\..\..\..\..\components\profiles\dis_c;..\..\..\..\..\components\profiles\gls;..\..\..\..\..\components\profiles\gus;..\..\..\..\..\components\profiles\gus_c;..\..\..\..\..\components\profiles\hids;..\..\..\..\..\components\profiles\hrrcps;..\..\..\..\..\components\profiles\hrs;..\..\..\..\..\components\profiles\hrs_c;..\..\..\..\..\components\profiles\hts;..\..\..\..\..\components\profiles\ias;..\..\..\..\..\components\profiles\lls;..\..\..\..\..\components\profiles\ndcs;..\..\..\..\..\components\profiles\otas;..\..\..\..\..\components\profiles\otas_c;..\..\..\..\..\components\profiles\pass;..\..\..\..\..\components\profiles\pass_c;..\..\..\..\..\components\profiles\pcs;..\..\..\..\..\components\profiles\rscs;..\..\..\..\..\components\profiles\rscs_c;..\..\..\..\..\components\profiles\rtus;..\..\..\..\..\components\profiles\sample;..\..\..\..\..\components\profiles\ths;..\..\..\..\..\components\profiles\ths_c;..\..\..\..\..\components\profiles\thscps;..\..\..\..\..\components\profiles\tps;..\..\..\..\..\components\profiles\wechat;..\..\..\..\..\components\sdk\;..\..\..\..\..\drivers\inc;..\..\..\..\..\external\freertos\include;..\..\..\..\..\external\segger_rtt;..\..\..\..\..\platform\include;..\..\..\..\..\platform\soc\include;..\..\..\..\..\platform\arch\arm\cortex-m\cmsis\core\include;..\Src\config;..\..\..\..\..\components\app_drivers\source;..\..\..\..\..\drivers\inc\hal;..\..\..\..\..\platform\boards;..\..\..\..\..\external\TinyUSB\src\common;..\..\..\..\..\external\TinyUSB\src\osal;..\..\..\..\..\external\TinyUSB\src;..\..\..\..\..\external\TinyUSB\src\device;..\..\..\..\..\external\TinyUSB\src\portable;..\..\..\..\..\external\TinyUSB\src\class\msc;..\..\..\..\..\external\TinyUSB\src\class\cdc;..\Src\\usbd_user;..\Src\bsp;..\..\..\..\..\external\freertos\include;..\..\..\..\..\external\freertos\portable\RVDS\ARM_CM4F;..\Src;..\Src\platform;..\Src\fatfs;..\..\..\..\..\components\graphics\lvgl_port\drv_adapter;..\..\..\..\..\components\drivers_ext\qspi_device
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x3000a000 size 0x36000
  scatter file: ..\..\..\..\..\platform\soc\linker\keil\flash_scatter_common.sct
  link misc: ..\..\..\..\..\platform\soc\linker\keil\rom_symbol.txt
  group gr_startup
    ../../../../../platform/arch/arm/cortex-m/keil/: Startup.S
  group gr_arch
    ../../../../../platform/soc/common/: gr_system.c gr_interrupt.c gr_platform.c
  group gr_soc
    ../../../../../platform/soc/src/: gr_soc.c
  group gr_board
    ../../../../../platform/boards/: board_SK.c
  group gr_stack_lib
    ../../../../../platform/soc/linker/keil/: ble_sdk.lib
  group gr_app_drivers
    ../../../../../components/libraries/app_key/: app_key_core.c app_key.c
    ../../../../../components/libraries/app_timer/: app_timer.c
    ../../../../../drivers/src/: app_dma.c app_pwr_mgmt.c app_gpiote.c app_io.c app_uart.c app_uart_dma.c app_qspi.c app_qspi_dma.c app_rtc.c
  group gr_libraries
    ../../../../../components/libraries/utility/: utility.c
    ../../../../../components/libraries/ring_buffer/: ring_buffer.c
    ../../../../../components/libraries/app_log/: app_log.c
    ../../../../../components/libraries/app_assert/: app_assert.c
  group external
    ../../../../../external/freertos/portable/GR55XX/: port_pm.c
    ../../../../../external/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../external/freertos/: timers.c tasks.c stream_buffer.c queue.c list.c heap_4.c event_groups.c croutine.c
    ../../../../../external/segger_rtt/: SEGGER_RTT.c
  group tusb_common
    ./../../../../../external/TinyUSB/src/common/: tusb_fifo.c
    ../../../../../external/TinyUSB/src/: tusb.c
  group tusb_device
    ../../../../../external/TinyUSB/src/device/: usbd.c usbd_control.c
  group tusb_portable
    ../../../../../external/TinyUSB/src/portable/goodix/gr552x/: dcd_gr552x.c
  group tusb_class
    ../../../../../external/TinyUSB/src/class/msc/: msc_device.c
    ../../../../../external/TinyUSB/src/class/cdc/: cdc_device.c
  group tusb_bsp
    ../Src/bsp/: tusb_bsp.c tusb_bsp.h
  group tusb_user
    ../Src/usbd_user/: msc_disk.c tusb_config.h usb_descriptors.c usb_descriptors.h
  group user_app
    ../Src/: main.c
    ../Src/config/: FreeRTOSConfig.h
    ../Src/platform/: user_periph_setup.c
  group fatfs
    ../Src/fatfs/: ff.c ffsystem.c ffunicode.c diskio_norflash.c
  group drv_adapter
    ../Src/driver/: drv_adapter_port_norflash.c
    ../../../../../components/drivers_ext/qspi_device/: qspi_norflash_v2.c
    ../../../../../components/graphics/lvgl_port/drv_adapter/: drv_adapter_norflash.c
